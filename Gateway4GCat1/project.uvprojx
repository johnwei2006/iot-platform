# Keil uVision project project.uvprojx, settings and files
target KB_Gateway_4GCAT1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KB_GATEWAY_4GCAT1 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER, STM32F407xx, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;config;packages\cJSON-latest;packages\crclib-v1.00\inc;.\rt_thread\components\net\at\include;.\rt_thread\libcpu\arm\common;.\rt_thread\libcpu\arm\cortex-m4;.\rt_thread\components\drivers\hwcrypto;.\rt_thread\components\drivers\include;.\rt_thread\components\drivers\include;.\rt_thread\components\drivers\include;.\rt_thread\components\drivers\spi;.\rt_thread\components\drivers\include;.\rt_thread\components\drivers\include;.\rt_thread\components\drivers\include;board;board\CubeMX_Config\Inc;.\libraries\HAL_Drivers;.\libraries\HAL_Drivers\config;.\libraries\HAL_Drivers\drv_flash;.\rt_thread\components\finsh;iap;lora;.\rt_thread\include;.\rt_thread\components\libc\compilers\common;.\rt_thread\components\libc\compilers\common\none-gcc;.\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;.\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;.\libraries\STM32F4xx_HAL\CMSIS\Include;packages\lora_radio_driver-latest\lora-radio;packages\lora_radio_driver-latest\lora-radio\include;packages\lora_radio_driver-latest\lora-radio\common;packages\lora_radio_driver-latest\ports;packages\lora_radio_driver-latest\ports\lora-module\inc;packages\lora_radio_driver-latest\samples;lte;.\packages\lora_radio_driver-latest\lora-radio\sx126x;.;.\config;.\console;.\flash_external;.\flash_internal;.\leds;.\utils;.\service;.\service_manager;.\transport_udp;.\lte;.\gateway_manager;.\modbus2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group applications
    ./applications/: main.c led.c
  group AT
    rt_thread/components/net/at/src/: at_client.c at_cli.c at_utils.c
  group CPU
    rt_thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt_thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt_thread/components/drivers/hwcrypto/: hwcrypto.c
    rt_thread/components/drivers/misc/: adc.c pin.c
    rt_thread/components/drivers/rtc/: rtc.c
    rt_thread/components/drivers/serial/: serial.c
    rt_thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt_thread/components/drivers/src/: workqueue.c ringbuffer.c ringblk_buf.c pipe.c waitqueue.c dataqueue.c completion.c
    rt_thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_adc.c drv_spi.c drv_rtc.c drv_wdt.c drv_crypto.c drv_usart.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group Kernel
    rt_thread/src/: irq.c object.c mem.c thread.c device.c components.c ipc.c mempool.c kservice.c clock.c timer.c scheduler.c idle.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cec.c stm32f4xx_hal_flash.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group finsh
    rt_thread/components/finsh/: shell.c cmd.c msh.c
  group libc
    rt_thread/components/libc/compilers/common/: time.c
  group crclib
    packages/crclib-v1.00/src/: crc8.c crc16.c crc32.c
  group lora-radio-driver
    packages/lora_radio_driver-latest/lora-radio/common/: lora-radio-timer.c
    packages/lora_radio_driver-latest/lora-radio/sx126x/: lora-radio-sx126x.c lora-spi-sx126x.c sx126x.c
  group lora-radio-driver/board
    packages/lora_radio_driver-latest/ports/lora-module/stm32_adapter/SX1268_LSD4RF-2R717N40/: sx1268-board.c
    packages/lora_radio_driver-latest/ports/lora-module/stm32_adapter/: lora-spi-board.c
  group config
    ./config/: config_manager.c config_json_converter.c
  group console
    ./console/: console.c console_encoder.c console_manager.c console_message_queue.c
  group iap
    iap/: iap.c
    ./iap/: md5.c
  group leds
    ./leds/: abstract_led.c led_manager.c
  group modbus
    ./modbus/: rs485.c modbus_parser.c modbus_manager.c
  group flash_internal
    ./flash_internal/: abstract_flash_internal.c stm32f4xx_flash.c
  group flash_external
    ./flash_external/: abstract_flash_external.c fm25_flash.c flash_block.c
  group service_udp
    ./service_udp/: service_gateway_heartbeat.c service_gateway_auth.c service_gateway_time_sync_request.c service_gateway_time_sync_response.c service_gateway_info_query.c service_gateway_sensor_report.c service_gateway_device_control.c service_gateway_reboot.c service_gateway_config.c service_gateway_config_query.c service_gateway_config_node.c service_gateway_config_node_query.c service_gateway_config_sensor.c service_gateway_config_sensor_query.c service_gateway_config_device.c service_gateway_config_device_query.c service_gateway_config_task.c service_gateway_config_task_query.c service_gateway_config_task_list.c service_gateway_upgrade.c
  group service_lora
    ./service_lora/: service_ping.c service_node_join_request.c service_notify_sensor_data_report_batch.c service_node_data_report.c service_node_device_control.c
  group service_manager
    ./service_manager/: service_manager_lora.c service_manager_udp.c
  group transport
    ./transport/: transport_message_queue.c transport_mem_pool_manager.c
  group transport_lora
    ./transport_lora/: lora_encoder.c lora_handler.c lora_service_encoder.c
  group transport_udp
    ./transport_udp/: transport_udp_handler.c transport_message_cache.c business_data_cache.c
  group transport_udp_encoder
    ./transport_udp_encoder/: transport_udp_encoder.c transport_udp_service_encoder.c
  group gateway_manager
    ./gateway_manager/: gateway_manager.c rtc_manager.c thread_manager.c
  group utils
    ./utils/: base64.c byte_utils.c cJSON.c cps_list.c utils.c time_utils.c
  group lora
    ./lora/: lora_driver.c lora_service.c
  group lte
    ./lte/: ec20_hal.c ec20_net.c ec20_protocol_udp.c ec20_protocol_http.c lte_app_tcp.c
  group power
    ./power_manager/: power_manager.c
  group watchdog
    ./watchdog/: watchdog_manager.c
  group sensor_read
    ./sensor_read/: sensor_read.c
